options:
  parameters:
    author: root
    generate_options: qt_gui
    id: header_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: ieee802_11.signal_field()
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    rangeType: int
    start: '10'
    step: '1'
    stop: '10000'
    value: '1500'
  states: {}
- name: max_symbols
  id: variable
  parameters:
    value: int(5 + 1 + ((16 + 800 * 8 + 6) * 2) / 24)
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '1500'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("x" for i in range(pdu_length)))
    period: interval
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    minoutbuf: max_symbols * 48 * 8
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.formatter()
    len_tag_key: '"packet_len"'
  states: {}
- name: ieee802_11_chunks_to_symbols_xx_0
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    minoutbuf: max_symbols * 48 * 8
  states: {}
- name: ieee802_11_mac_0_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: ieee802_11_mapper_0
  id: ieee802_11_mapper
  parameters:
    debug: 'True'
    encoding: encoding
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Header"'
    size: '48'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Overall"'
    size: '672'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Combined"'
    size: 672+48
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0_0, strobe, ieee802_11_mac_0_0, app in]
- [blocks_tagged_stream_mux_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [ieee802_11_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '1']
- [ieee802_11_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [ieee802_11_mac_0_0, phy out, ieee802_11_mapper_0, in]
- [ieee802_11_mapper_0, '0', digital_packet_headergenerator_bb_0, '0']
- [ieee802_11_mapper_0, '0', ieee802_11_chunks_to_symbols_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
