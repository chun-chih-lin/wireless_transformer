options:
  parameters:
    author: root
    generate_options: qt_gui
    id: fsk_generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 2300e6
    step: 5e6
    stop: 5920e6
    value: 2360e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0.0'
    step: '0.05'
    stop: '1.0'
    value: '.5'
  states: {state: disabled}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '5'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/chunchi/Desktop/wireless_transformer/gr-wireless_dump/examples/you_are_very_on_time.txt
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: sps
    sensitivity: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    gain0: gain_db
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-5-gdd01ef52
