options:
  parameters:
    author: root
    generate_options: qt_gui
    id: psk8_generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: PSK8
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: QAM16
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: QAM64
  id: variable_constellation
  parameters:
    const_points: '[-1.0000 + 1.0000j,  -1.0000 + 0.7143j,  -1.0000 + 0.1429j,  -1.0000 + 0.4286j,  -1.0000 - 1.0000j,  -1.0000 - 0.7143j,  -1.0000 - 0.1429j,  -1.0000 - 0.4286j,  -0.7143 + 1.0000j,  -0.7143 + 0.7143j,  -0.7143 + 0.1429j,  -0.7143 + 0.4286j,  -0.7143 - 1.0000j,  -0.7143 - 0.7143j,  -0.7143 - 0.1429j,  -0.7143 - 0.4286j,  -0.1429 + 1.0000j,  -0.1429 + 0.7143j,  -0.1429 + 0.1429j,  -0.1429 + 0.4286j,  -0.1429 - 1.0000j,  -0.1429 - 0.7143j,  -0.1429 - 0.1429j,  -0.1429 - 0.4286j,  -0.4286 + 1.0000j,  -0.4286 + 0.7143j,  -0.4286 + 0.1429j,  -0.4286 + 0.4286j,  -0.4286 - 1.0000j,  -0.4286 - 0.7143j,  -0.4286 - 0.1429j,  -0.4286 - 0.4286j,   1.0000 + 1.0000j,   1.0000 + 0.7143j,   1.0000 + 0.1429j,   1.0000 + 0.4286j,   1.0000 - 1.0000j,   1.0000 - 0.7143j,   1.0000 - 0.1429j,   1.0000 - 0.4286j,   0.7143 + 1.0000j,   0.7143 + 0.7143j,   0.7143 + 0.1429j,   0.7143 + 0.4286j,   0.7143 - 1.0000j,   0.7143 - 0.7143j,   0.7143 - 0.1429j,   0.7143 - 0.4286j,   0.1429 + 1.0000j,   0.1429 + 0.7143j,   0.1429 + 0.1429j,   0.1429 + 0.4286j,   0.1429 - 1.0000j,   0.1429 - 0.7143j,   0.1429 - 0.1429j,   0.1429 - 0.4286j,   0.4286 + 1.0000j,   0.4286 + 0.7143j,   0.4286 + 0.1429j,   0.4286 + 0.4286j,   0.4286 - 1.0000j,   0.4286 - 0.7143j,   0.4286 - 0.1429j,   0.4286 - 0.4286j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0,  1,  2,  3,  4,  5,  6,  7,  8,  9, 10, 11, 12, 13, 14, 15, 16, 17,  18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35,  36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53,  54, 55, 56, 57, 58, 59, 60, 61, 62, 63]'
    type: calcdist
  states: {}
- name: QPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 2300e6
    step: 5e6
    stop: 5920e6
    value: 2360e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0.0'
    step: '0.05'
    stop: '1.0'
    value: '.5'
  states: {state: disabled}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '5'
    stop: '70'
    value: '20'
  states: {}
- name: mod
  id: variable
  parameters:
    value: BPSK
  states: {state: disabled}
- name: mod
  id: variable
  parameters:
    value: QPSK
  states: {state: disabled}
- name: mod
  id: variable
  parameters:
    value: PSK8
  states: {state: disabled}
- name: mod
  id: variable
  parameters:
    value: QAM16
  states: {state: disabled}
- name: mod
  id: variable
  parameters:
    value: QAM64
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/chunchi/Desktop/wireless_transformer/gr-wireless_dump/examples/you_are_very_on_time.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 0, 1, 1, 1, 1)
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: mod
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: sps
    taps: firdes.root_raised_cosine(32, 32, 1.0, 0.35, 32*11*8)
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    gain0: gain_db
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-5-gdd01ef52
