options:
  parameters:
    author: root
    generate_options: qt_gui
    id: Record_Signal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 2400e6
    step: 5e6
    stop: 3800e6
    value: 2405e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '.65'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sample_per_input
  id: variable
  parameters:
    value: '128'
  states: {}
- name: save_filename
  id: variable
  parameters:
    value: save_mod + ".dat"
  states: {}
- name: save_folder
  id: variable
  parameters:
    value: '"/home/chunchi/Desktop/wireless_transformer/records/"'
  states: {}
- name: save_full_filename
  id: variable
  parameters:
    value: save_folder + save_prefix + save_filename
  states: {}
- name: save_mod
  id: variable
  parameters:
    value: '"PAM4"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"QPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"8PSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"QAM16"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"QAM64"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"CPFSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WBFM"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"AM-SSB"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"AM-DSB"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"GFSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-QPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-QAM64"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-QAM16"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-BPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"ZIGBEE-OQPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-LE2M"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-LE1M"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-S2Coding"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-S8Coding"'
  states: {}
- name: save_mod_0
  id: variable
  parameters:
    value: '"BT-GFSK-LE1M"'
  states: {state: disabled}
- name: save_prefix
  id: variable
  parameters:
    value: '"RML2016.10a.ReGen/"'
  states: {}
- name: ttl_save_sample
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: save_full_filename
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(ttl_save_sample*sample_per_input)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: carrier_freq
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-5-gdd01ef52
