options:
  parameters:
    author: root
    generate_options: qt_gui
    id: Record_Signal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 2400e6
    step: 5e6
    stop: 3800e6
    value: 2400e6
  states: {state: disabled}
- name: carrier_freq
  id: variable
  parameters:
    value: 2400e6
  states: {state: disabled}
- name: carrier_freq
  id: variable
  parameters:
    value: 2500e6
  states: {state: disabled}
- name: carrier_freq
  id: variable
  parameters:
    value: 2360e6
  states: {}
- name: distance
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 3
    label: Distance
    rangeType: int
    start: '5'
    step: '5'
    stop: '15'
    value: '5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '.65'
  states: {}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: interference
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 3, 1, 1
    label: Interference
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: sample_per_input
  id: variable
  parameters:
    value: '128'
  states: {}
- name: save_filename
  id: variable
  parameters:
    value: '"Non_process_" + save_prefix + "_" +  save_mod + "_TP" + tx_power + "_D" + str(distance) + "_SR" + str(int(samp_rate/1e6)) + "_CF" + str(int(carrier_freq/1e6)) + "_I" + str(interference) + ".dat"'
  states: {}
- name: save_folder
  id: variable
  parameters:
    value: '"/home/chunchi/Desktop/wireless_transformer/records/"'
  states: {}
- name: save_full_filename
  id: variable
  parameters:
    value: save_folder + save_prefix + "/" + save_filename
  states: {}
- name: save_mod
  id: variable
  parameters:
    value: '"PAM4"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"QPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"8PSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"QAM16"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"QAM64"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"CPFSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WBFM"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"AM-SSB"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"AM-DSB"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"GFSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"ZIGBEE-OQPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-LE2M"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-LE1M"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-S2Coding"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"BT-GFSK-S8Coding"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-BPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-QPSK"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-16QAM"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"WIFI-64QAM"'
  states: {state: disabled}
- name: save_mod
  id: variable
  parameters:
    value: '"RAND"'
  states: {}
- name: save_prefix
  id: variable
  parameters:
    value: '"Dataset_EIB_room328_to_Hallway"'
  states: {}
- name: ttl_save_sample
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: ttl_save_sample
  id: variable
  parameters:
    value: int(samp_rate/10)
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"40"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"50"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"30"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"20"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"-5"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"5"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"-10"'
  states: {}
- name: tx_power
  id: variable
  parameters:
    value: '"-20"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"-15"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"10"'
  states: {state: disabled}
- name: tx_power
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: save_full_filename
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(ttl_save_sample*sample_per_input)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate
    type: complex
    ymax: '0.25'
    ymin: '-0.25'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: carrier_freq
    gain0: gain_db
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-5-gdd01ef52
