options:
  parameters:
    author: root
    generate_options: qt_gui
    id: cpfsk_generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ubuntu2204/Desktop/wireless_transformer/gr-wireless_dump/examples/you_are_very_on_time.txt
    repeat: 'True'
    type: byte
  states: {}
- name: digital_cpmmod_bc_0
  id: digital_cpmmod_bc
  parameters:
    L: '1'
    beta: '0.35'
    mod_index: '0.5'
    samples_per_symbol: sps
    type: analog.cpm.TFM
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', digital_cpmmod_bc_0, '0']
- [digital_cpmmod_bc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_cpmmod_bc_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
